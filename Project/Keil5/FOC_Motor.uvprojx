# Keil uVision project FOC_Motor.uvprojx, settings and files
target Test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32M5533 Cmsemicon
  pack: Cmsemicon.CMS32-Series.1.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: FOC_Motor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\CODE\HAL\CORE\Include;..\..\CODE\HAL\FWLIB\inc;..\..\CODE\APL;..\..\CODE\HAL\CORE\Source\ARM;..\..\CODE\HDL\Include;..\..\CODE\FML\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APL
    ../../CODE/APL/: isr.c main.c
  group FML
    ../../CODE/FML/Source/: Hall_Commutation.c Motor_Control.c Motor_math.c Motor_SVPWM.c Motor_PID.c UART_Process.c
  group HDL
    ../../CODE/HDL/Source/: ADC_Config.c CCP_Config.c EPWM_Config.c TIM_Config.c UART_Config.c System_Config.c retarget.c
  group HAL
    ../../CODE/HAL/CORE/Source/: system_CMS32M55xx.c
    ../../CODE/HAL/CORE/Source/ARM/: startup_CMS32M55xx.s
    ../../CODE/HAL/FWLIB/src/: acmp.c adc0.c adc1.c ccp.c crc.c epwm.c fmc.c gpio.c hwdiv.c i2c.c opa.c pga.c ssp.c system.c timer.c uart.c wdt.c wwdt.c
